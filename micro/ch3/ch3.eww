<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\asm_template.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\asm_template_explained.ewp</path>
  </project>
  <batchBuild/>
</workspace>


